# Keil uVision project test.uvprojx, settings and files
target test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: test +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\hardware\led;..\hardware\key;..\hardware\exti_test;..\hardware\lcd_drive;..\hardware\touch;..\hardware\GUI;..\hardware\w25q64;..\hardware\tftDisp;..\hardware\FFT;..\DSP_LIB\Include;..\DSP_LIB;..\hardware\spin;..\hardware\windowsframe;..\hardware\DataOperation
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Application/User
    ../Src/: common.c main.c gpio.c adc.c dma.c fsmc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group App/App
    ../hardware/key/: key.c
    ../hardware/led/: led.c
    ../hardware/exti_test/: exti_test.c
    ../hardware/lcd_drive/: lcd_drive.c
    ../hardware/touch/: touch.c
    ../hardware/GUI/: GUI.c
    ../hardware/w25q64/: w25q64.c
    ../hardware/tftDisp/: tftDisp.c
    ../hardware/FFT/: fft.c
    ../hardware/spin/: spin.c
    ../hardware/windowsframe/: windowsframe.c
    ../hardware/DataOperation/: DataOperation.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.1.1
